# Keil uVision project LDC1614_ACK_Test.uvprojx, settings and files
target LDC1614_ACK_Test (6070000::V6.7::.\ARMCLANG)
  device: STM32C011F6UxTR STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LDC1614_ACK_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C011xx
  c include: ..\App;..\Driver;..\..\Drivers\STM32C0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include;..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group CMSIS Startup
    ../../Startup/: startup_stm32c011xx.s
    ../../CMSIS/: system_stm32c0xx.c
  group Standalone ACK Test
    ../App/: main.c
    ../Driver/: test_board.c test_i2c.c test_board.h test_i2c.h
    ../: README.md
