# Keil uVision project LDC1614.uvprojx, settings and files
target LDC1614 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LDC1614 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD;USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\App;..\Driver;..\Device;..\Service;..\CMSIS;..\Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group App
    ../App/: main.c app.c app.h display.c display.h console.c console.h
  group Driver
    ../Driver/: board.c board.h hard_i2c.c hard_i2c.h uart.c uart.h oled.c oled.h button.c button.h adc_temp.c adc_temp.h flash_param.c flash_param.h
  group Device
    ../Device/: ldc1614.c ldc1614.h
  group Service
    ../Service/: measure.c measure.h protocol.c protocol.h
