# Keil uVision project LDC1614_C011.uvprojx, settings and files
target LDC1614_C011 (6070000::V6.7::.\ARMCLANG)
  device: STM32C011F6UxTR STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LDC1614_C011 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C011xx
  c include: ..\App;..\Device;..\Driver;..\Service;..\CMSIS;..\Drivers\STM32C0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32C0xx\Include;..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/Startup
    ../Startup/: startup_stm32c011xx.s
    ../CMSIS/: system_stm32c0xx.c
  group App
    ../App/: main.c app.c display.c console.c
  group Driver
    ../Driver/: board.c hard_i2c.c uart.c adc_temp.c button.c flash_param.c oled.c
    ../test/Driver/: test_board.c
  group Device/Service
    ../Device/: ldc1614.c
    ../Service/: measure.c protocol.c
  group STM32C0 LL
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_ll_gpio.c stm32c0xx_ll_exti.c stm32c0xx_ll_rcc.c stm32c0xx_ll_utils.c stm32c0xx_ll_i2c.c stm32c0xx_ll_usart.c stm32c0xx_ll_adc.c stm32c0xx_ll_pwr.c
  group Documentation
    ../: README.md
software components: CMSIS:CORE 4.3.0
