# Keil uVision project LDC1614_F103_Flow_STLink.uvprojx, settings and files
target LDC1614_F103_FLOW_SW (6070000::V6.7::.\ARMCLANG)
  device: STM32C011F6UxTR STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x80077FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LDC1614_F103_FLOW_SW +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ACK_COMPARE_PROFILE=1,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C011xx
  c include: ..\App;..\Device;..\Driver;..\..\ack_compare\Driver;..\..\test\Driver;..\..\Drivers\STM32C0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include;..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x1800
  group CMSIS Startup
    ../../Startup/: startup_stm32c011xx.s
    ../../CMSIS/: system_stm32c0xx.c
    ../../ack_compare/Driver/: ack_port.c
  group Original F103 LDC Flow
    ../App/: main.c f103_flow.c f103_flow.h
    ../../ack_compare/Driver/: wake_i2c.c wake_i2c.h
    ../../test/Driver/: test_board.c test_board.h test_i2c.h
    ../: README.md
    ../Device/: ldc1614.c ldc1614.h
    ../Driver/: f103_i2c_adapter.c flow_bus.h hard_i2c.h board.h
