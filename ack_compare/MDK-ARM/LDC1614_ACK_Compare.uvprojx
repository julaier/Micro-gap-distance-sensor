# Keil uVision project LDC1614_ACK_Compare.uvprojx, settings and files
target LDC1614_ACK_B_OD3 (6070000::V6.7::.\ARMCLANG)
  device: STM32C011F6UxTR STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x80077FF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LDC1614_ACK_B_OD3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ACK_COMPARE_PROFILE=1,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C011xx
  c include: ..\App;..\Driver;..\..\test\Driver;..\..\Drivers\STM32C0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32C0xx\Include;..\..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x1800
  group CMSIS Startup
    ../../Startup/: startup_stm32c011xx.s
    ../../CMSIS/: system_stm32c0xx.c
    ../Driver/: ack_port.c
  group I2C ACK Comparison
    ../App/: main.c wake_diag.c wake_diag.h
    ../Driver/: wake_i2c.c wake_i2c.h
    ../../test/Driver/: test_board.c test_board.h test_i2c.h
    ../: README.md
target LDC1614_ACK_A_LEGACY (6070000::V6.7::.\ARMCLANG)
  device: STM32C011F6UxTR STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: as above
  output: LDC1614_ACK_A_LEGACY +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ACK_COMPARE_PROFILE=0,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=48000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32C011xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0x1800
